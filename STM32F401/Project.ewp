# IAR project Project.ewp, settings and files
configuration STM32F40_41xxx (ARM, debug)
  General.OGChipSelectEditMenu: STM32F417IG ST STM32F417IG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F40_41xxx; USE_STM324xG_EVAL
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM3240_41_G_EVAL
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32F401xx (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F401xE ST STM32F401xE
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; HSE_VALUE=16000000; STM32F401xx; DEBUG=1
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32_EVAL\Common; C:\Users\electronika\Desktop\Иван_практикант\1\STM32F4xx_DSP_StdPeriph_Lib_V1.8.0\Libraries\CMSIS\Include; D:\!!!!учеба\диплом\STM32F4xx_StdPeriph_Templates\EWARM_my\include
configuration STM32F411xE (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F411RE ST STM32F411RE
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F411xE
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32_EVAL\Common
configuration STM32F446xx (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F446ZE ST STM32F446ZE
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F446xx
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc
configuration STM32F469_479xx (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F479NI ST STM32F479NI
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F469_479xx
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM324x9I_EVAL
configuration STM32F410xx (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F410RB ST STM32F410RB
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F410xx
  ICCARM.CCIncludePath2: as above
configuration STM32F412xG (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F412ZG ST STM32F412ZG
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F412xG
  ICCARM.CCIncludePath2: as above
configuration STM32F413_423xx (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F413ZH ST STM32F413ZH
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F413_423xx
  ICCARM.CCIncludePath2: as above
  group CMSIS
    ../: system_stm32f4xx.c
  group Doc
    ../: readme.txt
  group EWARM
    ../../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f40_41xxx.s startup_stm32f410xx.s startup_stm32f411xe.s startup_stm32f412xg.s startup_stm32f427_437xx.s startup_stm32f429_439xx.s startup_stm32f446xx.s startup_stm32f469_479xx.s
  group STM32F4xx_StdPeriph_Driver
    ../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group User
    ../: main.c stm32f4xx_it.c
  group User/include
    include/: config.h
  group User/include/comm
    include/comm/: comm.h comm_ModbusConfig.h comm_ModbusCrc.h comm_ModbusEvent.h comm_ModbusFrame.h comm_ModbusRtu.h comm_ModBusTimers.h comm_SerialComm.h
  group User/include/global
    include/global/: g_hardware.h g_InterruptUpdate.h g_Rom.h std.h
  group User/include/math
    include/math/: mathemath.h
  group User/include/peref
    include/peref/: p_tempObserver.h p_vibrIvd3.h p_voltControl.h
  group User/src/comm
    src/comm/: comm.c comm_ModbusRtu.c comm_SerialComm.c
  group User/src/global
    src/global/: g_InitHardware.c g_InterruptUpdate.c g_Rom.c
  group User/src/peref
    src/peref/: p_tempObserver.c p_vibrIvd3.c p_voltControl.c
